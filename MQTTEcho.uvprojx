# Keil uVision project MQTTEcho.uvprojx, settings and files
target Google (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.8.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MQTTEcho
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MBEDTLS_MSG_INFO=1
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Code
    ./: main.c demo.c pkey.h
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Security:mbed TLS 2.6.1, Compiler:I/O:STDOUT 1.4.0, Network:CORE 7.8.0, Network:Interface:ETH 7.8.0, Network:Service:DNS Client 7.8.0, Network:Service:SNTP Client 7.8.0, Network:Socket:BSD 7.8.0, Network:Socket:TCP 7.8.0, Network:Socket:UDP 7.8.0, CMSIS Driver:Ethernet MAC 2.7.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, Device:SCU 1.1.0, Device:Startup 1.0.0, IoT Client:Google 1.0.0, IoT Client:MQTTClient-C 1.1.0, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:MDK Network 1.0.0
